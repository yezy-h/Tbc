# Keil uVision project TemperatureController.uvproj, settings and files
target TemperatureController (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TemperatureController +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210B_EVAL
  c include: ..\APP;..\BSP;..\FWLib\inc;..\Startup;..\uCOS-II\Source;..\uCOS-II\uC-CPU;..\uCOS-II\uC-LIB;..\uCOS-II\Ports;..\CM3;..\BSP\ds18b20;..\BSP\fan;..\BSP\ads1100;..\BSP\bluetooth;..\BSP\m25p16;..\BSP\lcd1602;..\BSP\pid
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../Startup/: stm32f10x_startup.s
  group APP
    ./: app.c stm32f10x_it.c
  group BSP
    ../BSP/: bsp.c delay.c
  group FWLib
    ../FWlib/SRC/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_can.c stm32f10x_iwdg.c stm32f10x_tim.c stm32f10x_i2c.c stm32f10x_spi.c
  group uC-OS-II/Port
    ../uCOS-II/Ports/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group uC-OS-II/CPU
    ../uCOS-II/uC-CPU/: cpu_a.asm
  group uC-OS-II/Source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group Documentation
    ./: readme.txt
  group CM3
    ../CM3/: core_cm3.c system_stm32f10x.c
  group ds18b20
    ../BSP/ds18b20/: ds18b20.c
  group fan
    ../BSP/fan/: fan.c
  group ads1100
    ../BSP/ads1100/: ads1100.c
  group bluetooth
    ../BSP/bluetooth/: bluetooth.c
  group m25p16
    ../BSP/m25p16/: m25p16.c
  group lcd1602
    ../BSP/lcd1602/: lcd1602.c
  group pid
    ../BSP/pid/: pid.c
